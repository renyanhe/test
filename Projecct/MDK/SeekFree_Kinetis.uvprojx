# Keil uVision project SeekFree_Kinetis.uvprojx, settings and files
target SeekFree_MK66FX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK66FX1M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IROM(0x00000000,0x100000) IROM2(0x10000000,0x40000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SeekFree_Kinetis
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\USER\inc;..\USER\src;..\..\Libraries\startup\CoreSupport;..\..\Libraries\startup\DeviceSupport\MDK-ARM;..\..\Libraries\startup\DeviceSupport;..\..\Libraries\drives\inc;..\..\Libraries\drives\src;..\..\Libraries\seekfree;..\..\Libraries\FatFs;..\..\Libraries\FatFs\option;..\..\FreeRTOS;..\..\FreeRTOS\portable\MemMang;..\..\FreeRTOS\include;..\USER\src;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff0000 size 0x40000
  group startup
    ../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK66F18.s
    ../../Libraries/startup/DeviceSupport/: system_MK66.c
  group drives_c
    ../../Libraries/drives/src/: common.c misc.c MK60_adc.c MK60_cmt.c MK60_dac.c MK60_dma.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_pit.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_systick.c MK60_uart.c MK60_wdog.c
  group user_c
    ./: task_control.c task_camera.c task_UI.c task_init.c
    ../USER/src/: isr.c main.c
    ../../Libraries/: version.txt
  group seekfree
    ../../Libraries/seekfree/: SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h font.c font.h
  group fatfs
    ../../Libraries/FatFs/: 00readme.txt diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group FreeRTOS_CORE
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group user_other
    ../USER/: cpustate.c
